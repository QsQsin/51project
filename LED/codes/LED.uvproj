# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c LCD1602.h delay.c delay.h uart.c uart.h timer.c timer.h iic.c iic.h AT24C02.c AT24C02.h adc0809.c adc0809.h
